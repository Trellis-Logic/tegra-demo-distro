DEPENDS += "tegrademo-devicetree-overlay"
